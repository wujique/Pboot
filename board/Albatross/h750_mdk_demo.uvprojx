# Keil uVision project h750_mdk_demo.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: h750_mdk_demo
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Core\Inc;.\board;..\..\boot;..\..\device;..\..\mcu\stm32h750\mcu_dev;..\..\mcu\stm32h750\CMSIS\Include;..\..\mcu\stm32h750\CMSIS\Device\ST\STM32H7xx\Include;..\..\mcu\stm32h750\STM32H7xx_HAL_Driver\Inc;..\..\mcu\stm32h750\STM32H7xx_HAL_Driver\Inc\Legacy;..\..\petite;..\..\Utilities\cjson
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\Objects\h750_mdk_demo.sct
  group core
    ./Core/Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c system_stm32h7xx.c
    ./Core/Startup/: startup_stm32h750xx.s
  group dev
    ../../device/: test_qspi.c stm32746g_qspi.c Qspi_Flash_Test.c
  group mcu
    ../../mcu/stm32h750/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group mcu_dev
    ../../mcu/stm32h750/mcu_dev/: mcu_uart.c mcu_misc.c
  group boot
    ../../boot/: pboot_main.c partition.c check_firmware.c ymodem.c
  group petite
    ../../petite/: log.c alloc.c math.c p_kfifo.c bus_uart.c
  group board
    ./board/: board.c
